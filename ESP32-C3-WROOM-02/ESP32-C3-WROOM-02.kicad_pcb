# Repository 74th/esp32-dev-boards

File README.md:

# ESP32 Dev Boards

- [ESP32-Writer](ESP32-writer): ESP-Prog 互換ボックスピンヘッダをもつ CH340C を使った ESP32 Writer
- [ESP32-S3-WROOM-1](ESP32-S3-WROOM-1): ESP32-S3-WROOM-1 の開発ボード
- [ESP32-C3-WROOM-02](ESP32-C3-WROOM-02): ESP32-C3-WROOM-02 の開発ボード
- [ESP32-C3-MINI-1](ESP32-C3-MINI-1): ESP32-C3-MINI-1 の開発ボード
- [ESP32-C6-WROOM-1](ESP32-C6-WROOM-1): ESP32-C6-WROOM-1 の開発ボード
- [ESP32-H2-MINI-1](./ESP32-H2-MINI-1/basic): ESP32-H2-MINI-1 の開発ボード
- [ESP32-MINI-DevBoard](ESP32-WROOM-32): ESP32-WROOM-32 の開発ボード

## 利用している外部リソース

- https://github.com/espressif/kicad-libraries

## License

MIT License

公開している基板データは自由に利用可能です。販売はご遠慮いただけると助かります。

## KiCad design ESP32-C3-WROOM-02/ESP32-C3-WROOM-02.kicad_pcb

File ESP32-C3-WROOM-02/README.md:

# ESP32-C3 Dev Board

ESP32-C3-WROOM-02 を使った開発ボード

- 10 ピンブレッドボードに挿しても、左右 1 ピン空いている
- ESP-Prog の USB シリアル変換のボックスピンヘッダを持つ
- USB Type-C をもつ

BOOTH でモジュール付きキットを販売中です。<br/>
https://74th.booth.pm/items/4378573

同じピン配置の以下のモジュールでも利用可能です。

- ESP8684-WROOM-02C

## v1.2.1

こちらのバージョンは発売していません。

### 変更点

- GPIO20、GPIO21のUARTのU0RXD/U0TXDのシルクが逆になっていたのを修正

### ドキュメント

- 回路図 [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp3s-c3-devboard%2Fv1.2.1%2FESP32-C3-WROOM-02%2FESP32-C3-WROOM-02.kicad_sch)
- PCB [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp3s-c3-devboard%2Fv1.2.1%2FESP32-C3-WROOM-02%2FESP32-C3-WROOM-02.kicad_pcb)

### ピンマップ、部品表

v1.2.0 と同じです。そちらを参照ください。

## v1.2.0

## 既知の不具合 Errata

UARTのTX0/RX0 のシルクの表示が逆になっています。"T"と書かれたピンがRX0、"R"と書かれたピンがTX0です。

- GPIO20: U0RXD
- GPIO21: U0TXD

### 変更点

- USB DM/DP にダンピング抵抗を追加
- 電源にダイオードを追加
- ESP-C3-DevKitC-02 互換の配置を止めた

### ピンマップ

### ドキュメント

- 回路図 [pdf](esp32c3devboard-1.2.0-semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp3s-c3-devboard%2Fv1.2.0%2FESP32-C3-WROOM-02%2FESP32-C3-WROOM-02.kicad_sch)
- PCB [pdf](esp32c3devboard-1.2.0-pcb.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp3s-c3-devboard%2Fv1.2.0%2FESP32-C3-WROOM-02%2FESP32-C3-WROOM-02.kicad_pcb)

### 部品表

| Reference | Name                                           | Quantity |
| --------- | ---------------------------------------------- | -------- |
| C1,C4,C7  | Capacitor 0603 100nF                           | 3        |
| C2,C5,C6  | Capacitor 0603 10uF                            | 3        |
| C3        | Capacitor 0603 1uF                             | 1        |
| D1        | LED 0805 LED                                   | 1        |
| D2        | Schottky barrier diode SOD-123W PMEG2010ER,115 | 1        |
| J1        | Box Pin Header 2x3 Pitch 1.27mm                | 1        |
| J2        | USB Type-C Receptacle                          | 1        |
| R1,R3     | Register 0603 10kΩ                             | 2        |
| R2,R4     | Register 0603 10Ω                              | 2        |
| R5        | Register 0603 1kΩ                              | 1        |
| R6,R7     | Register 0603 5.1kΩ                            | 2        |
| SW1,SW2   | Button SKRPABE010                              | 2        |
| U1        | WiFi MCU Module ESP32-C3-WROOM-02              | 1        |
| U2        | Regulator 3.3V SOT-223 AMS1117-3.3             | 1        |

## v1.1.0

- 回路図 [pdf](esp32c3devboard-1.1.0-semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp3s-c3-devboard%2Fv1.1.0%2FESP32-C3-WROOM-02%2FESP32-C3-WROOM-02.kicad_sch)
- PCB [pdf](esp32c3devboard-1.1.0-pcb.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp3s-c3-devboard%2Fv1.1.0%2FESP32-C3-WROOM-02%2FESP32-C3-WROOM-02.kicad_pcb)

### 部品表

| 指定子    | 名称                                      | 数量 |
| --------- | ----------------------------------------- | ---- |
| R1        | 0805 レジスタ 1k                          | 1    |
| R2,R5     | 0805 レジスタ 10k                         | 2    |
| R3,R4     | 0805 レジスタ 5.1k                        | 2    |
| C1,C4,C6  | 0805 キャパシタ 10u                       | 3    |
| C2,C3,C7  | 0805 キャパシタ 100n                      | 3    |
| C5        | 0805 キャパシタ 1u                        | 1    |
| D1        | 0805 LED                                  | 1    |
| J3        | UART ボックスピンヘッダ 2.3 1.27mm ピッチ | 1    |
| J4        | USB 2.0 Type-C ミッドマウントソケット     | 1    |
| U1        | 3.3V レギュレータ AMS1117-3.3             | 1    |
| U2        | ESP32-C3-WROOM-02                         | 1    |
| SW1(EN)   | プッシュスイッチ SKRPABE010(EN)           | 1    |
| SW1(BOOT) | プッシュスイッチ SKRPABE010(BOOT)         | 1    |

- ESP32-C3-WROOM-02 は非常に熱に弱いモジュールです。ボード裏面にはサーマルパッドをはんだづけするための穴が空いていますが、熱を与えすぎに注意してください。BOOTH のキットでは熱伝導テープを添付しています。カットして、モジュールに貼り付けて、青いテープ、透明テープを剥がして利用ください。モジュールが浮きすぎないように押さえつけて利用ください。

Parts:
C1, C4, C7: 100n; Capacitor_0603_1608
C2, C5, C6: 10u; Capacitor_0603_1608
C3: 1u; Capacitor_0603_1608
CH1, CH2: Pin_10; PinOut_Pin_10
D1: LED; LED_0805_2012
D2: PMEG2010ER,115; Package_SOD123W
J1: ESP-Prog-ProgramCOM_RECV; Connector_BoxPinHeader_2x03_P1.27mm
J2: USB2.0_C; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
R1, R3: 10k; Register_0603_1608
R2, R4: 10; Register_0603_1608
R5: 1k; Register_0603_1608
R6, R7: 5.1k; Register_0603_1608
SW1, SW2: SW_Push; Switch_SKRPABE010
U1: ESP32-C3-WROOM-02
U2: AMS1117-3.3; Package_SOT-223-3

Connections:
+3V3: C1.1, C2.1, C4.1, C5.1, CH1.1, R1.1, R3.1, R5.1, U1.1 (3V3), U2.2 (VO)
+5V: C6.1, C7.1, CH1.9, D2.1 (K), J1.2 (VCC), U2.3 (VI)
/EN: C3.1, CH1.2, J1.1 (EN), R1.2, SW2.2, U1.2 (EN/CHIP_PU)
/IO0: CH2.2, U1.18 (GPIO0/ADC1_CH0/XTAL_32K_P)
/IO1: CH2.3, U1.17 (GPIO1/ADC1_CH1/XTAL_32K_N)
/IO2: CH2.4, U1.16 (GPIO2/ADC1_CH2)
/IO3: CH2.5, U1.15 (GPIO3/ADC1_CH3)
/IO4: CH1.3, U1.3 (GPIO4/ADC1_CH4)
/IO5: CH1.4, U1.4 (GPIO5/ADC2_CH0)
/IO6: CH1.5, U1.5 (GPIO6)
/IO7: CH1.6, U1.6 (GPIO7)
/IO8: CH1.7, R3.2, U1.7 (GPIO8)
/IO9: CH1.8, J1.6 (IO0), SW1.2, U1.8 (GPIO9)
/IO10: CH2.10, U1.10 (GPIO10)
/IO18: CH2.7, R4.2, U1.13 (GPIO18/USB_D-)
/IO19: CH2.6, R2.2, U1.14 (GPIO19/USB_D+)
/IO20: CH2.9, J1.5 (RXD0), U1.11 (GPIO20/U0RXD)
/IO21: CH2.8, J1.3 (TXD0), U1.12 (GPIO21/U0TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, CH1.10, CH2.1, D1.1 (K), J1.4 (GND), J2.4 (GND), R6.2, R7.2, SW1.1, SW2.1, U1.9 (GND), U1.19 (GND), U2.1 (GND)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), J2.1 (VBUS)
unnamed: J2.5 (CC1), R7.1
unnamed: J2.6 (CC2), R6.1
unnamed: J2.3 (D+), R2.1
unnamed: J2.2 (D-), R4.1

Notes on the sheet:
ESP32-C3 Module
Pinout
Programing Port
Power
USB

Board: 2 copper layers, 25.4 x 29.2 mm, 24 parts (16 on the bottom side), 25 nets.

## KiCad design ESP32-Writer-CH9102F/ESP-Writer-CH9102F.kicad_pcb

File ESP32-Writer-CH9102F/README.md:

# ESP32 Write Pro CH9102F: ESP32 write tool with automatic download control using CH9102F

🇯🇵 ESP32 Write Pro CH9102F: CH9102F使用自動ダウンロード制御付きESP32書き込みツール

## features

- Uses WCH CH9102F
- Use CH32V003 for automatic download control and reliable timing control
- Switch to download mode with button
- ESP-Prog compatible with 1.24mm 2x3 box pin headers for ESP32 writing
- Solder jumper to switch between 3.3V or 5V supply voltage for ESP-Prog compatible ports

🇯🇵

- WCH CH9102Fを使用
- 自動ダウンロード制御に、CH32V003を使用して、確実なタイミングで制御する
- ボタンによるダウンロードモードへ切り替え
- ESP-Prog 互換ESP32書き込み用1.24mm 2x3ボックスピンヘッダ搭載
- はんだジャンパで、ESP-Prog互換ポートの電源電圧を、3.3Vまたは5Vに切り替え可能

## ESP-Prog Port Pinout / ESP-Progポートピンアサイン

## Mechanism for automatic download control / 自動ダウンロード制御の仕組み

The MCU reads the DTR and RTS pins of the CH9102F's UART and performs the following operations

- (1) DTR is operated from H to L (enters download boot)
  - BOOT pin: 0
  - Wait 100ms
  - EN pin: 0
  - Wait 100ms
  - EN pin: 1
  - 100-ms wait
  - BOOT pin: 1
- (2) RTS is operated from H to L (to reset)
  - EN pin: 0
  - 100ms wait
  - EN pin: 1

Using esptool.py, the device automatically enters download boot with operation (1) and is reset with operation (2) after writing.

Translated with DeepL.com (free version)

🇯🇵

CH9102FのUARTのDTR、RTSピンをMCUで読み取り、以下の操作をします。

- (1) DTRがH→Lに操作された（ダウンロードブートに入る）
  - BOOTピン: 0
  - 100ms待機
  - ENピン: 0
  - 100ms待機
  - ENピン: 1
  - 100ms待機
  - BOOTピン: 1
- (2) RTSがH→Lに操作された（リセットする）
  - ENピン: 0
  - 100ms待機
  - ENピン: 1

esptool.pyを使うと、(1)の動作で自動的にダウンロードブートに入り、書き込み後(2)の動作でリセットされます。

## Caution / 注意

VCC of the ESP-Prog port is initially set to 5 V. To switch to 3.3 V, switch the solder jumper.

🇯🇵

ESP-ProgポートのVCCは初期は5Vになっています。3.3Vに切り替える場合は、はんだジャンパを切り替えてください。

## v1.0.1

- Semantics/回路図 [PDF](./ESP-Writer-CH9102F-v1.0.1-semantics.pdf) [KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-writer-ch9102f%2Fv1.0.1%2FESP32-Writer-CH9102F%2FESP-Writer-CH9102F.kicad_sch)
- PCB [KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-writer-ch9102f%2Fv1.0.12FESP32-Writer-CH9102F%2FESP-Writer-CH9102F.kicad_pcb)

### BOM

| Reference | Name                              | Package         | Quantity |
| --------- | --------------------------------- | --------------- | -------- |
| C1-5      | Capacitor 100nF                   | SMD I0603 M1608 | 5        |
| C6-7      | Capacitor 10uF                    | SMD I0603 M1608 | 2        |
| D1        | LED RED                           | SMD I0805 M2012 | 1        |
| D2-3      | LED BLUE                          | SMD I0805 M2012 | 2        |
| D4        | LED YELLOW                        | SMD I0805 M2012 | 1        |
| F1        | PolyFuse 1812 KT6-1100SMDI        | I1206 M3216     | 1        |
| J1        | USB Type-C Receptacle             |                 | 1        |
| J2        | Box Pin Header 2x3 Pitch 1.27mm   |                 | 1        |
| JP1       | Jumper Jumper_3_Open              |                 | 1        |
| R1-3      | Register 5.1kΩ                    | SMD I0603 M1608 | 3        |
| R4-5,R7   | Register 10kΩ                     | SMD I0603 M1608 | 3        |
| R6        | Register 1kΩ                      | SMD I0603 M1608 | 1        |
| R8-9      | Register 10Ω                      | SMD I0603 M1608 | 2        |
| SW1       | Button SKRPABE010                 |                 | 1        |
| U1        | USB to Serial Port IC WCH CH9102F | QFN-24          | 1        |
| U2        | MCU WCH CH32V003J4M6              | SOIC-8          | 1        |
| U3        | USB Power Protection IC CH213K    | SOT-23          | 1        |
| U4        | Regulator 3.3V AMS1117-3.3        | SOT-89          | 1        |

Parts:
C1, C2, C3, C4: 100n; Capacitor_0603_1608
C5: 22u; Capacitor_0603_1608
C6, C7: 10u; Capacitor_0603_1608
CH1: Pin_7; PinOut_Pin_7
D1: RED; LED_0805_2012
D2, D3: BLUE; LED_0805_2012
F1: KT6-1100SMDI; Package_Fuse_1812_4532m
J1: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
J2: ESP-Prog-ProgramCOM_SEND; Connector_BoxPinHeader_2x03_P1.27mm
JP1: Jumper_3_Open; SolderJumper-3
Q1, Q2: 2N7002; Package_SOT-23
R1, R2, R3: 5.1k; Register_0603_1608
R4, R5: 10k; Register_0603_1608
U1: CH9102F; Package_QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_hand
U3: CH213K; Package_SOT-23
U4: AMS1117; Package_SOT-89-3

Connections:
+3V3: C7.1, CH1.2, JP1.3 (B), U3.3 (VI+), U4.2 (VO)
+5V: C3.1, C4.1, C6.1, CH1.1, F1.2, JP1.1 (A), U1.7 (VDD5), U1.8 (VBUS), U4.3 (VI)
/D+: J1.3 (D+), U1.3 (D+)
/D-: J1.2 (D-), U1.4 (D-)
/DTR: Q1.1 (G), Q2.2 (S), U1.23 (~DTR)
/ESP_BOOT: CH1.6, J2.6 (IO0), Q2.3 (D)
/ESP_EN: CH1.7, J2.1 (EN), Q1.3 (D)
/RTS: Q1.2 (S), Q2.1 (G), U1.19 (~RTS)
/USB_RXD: CH1.3, J2.3 (RXD0), U1.20 (RXD)
/USB_TXD: CH1.4, J2.5 (TXD0), U1.21 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, CH1.5, J1.4 (GND), J2.4 (GND), R1.2, R2.2, R3.2, U1.2 (GND), U1.25 (GND), U3.1 (GND), U4.1 (GND)
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), R5.1
unnamed: J1.5 (CC1), R2.1
unnamed: J1.6 (CC2), R1.1
unnamed: F1.1, J1.1 (VBUS)
unnamed: C5.1, J2.2 (VCC), JP1.2 (C)
unnamed: R5.2, U1.13 (RXS/GPIO1)
unnamed: R4.2, U1.14 (TXS/GPIO0)
VDD: C1.1, C2.1, D1.2 (A), D2.2 (A), D3.2 (A), U1.5 (VIO), U1.6 (V3), U3.2 (VO-)

Notes on the sheet:
USB-Power
ESP-Prog Port
AutoBoot
CH9102F
Pinout

Board: 2 copper layers, 34.2 x 19.5 mm, 26 parts (16 on the bottom side), 21 nets.

Other parts of the board:
MISC-ICON: LOGO; Logo_74th_4mm

## KiCad design ESP32-H2-MINI-1/basic-b/ESP32-H2-MINI-1-basic-b.kicad_pcb

File ESP32-H2-MINI-1/basic-b/README.md:

# ESP32-H2-MINI-1 DevBoard

ESP32-H2-MINI-1 を使った開発ボード

BoxPinHeader は ESP-Prog の UART と接続できます。

## v1.0.1

- Semantics [pdf](./ESP32-H2-MINI-1-basic_v1.0.1_semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-h2-mini-1-basic%2Fv1.0.1%2FESP32-H2-MINI-1%2Fbasic%2FESP32-H2-MINI-1-basic.kicad_sch)
- PCB [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-h2-mini-1-basic%2Fv1.0.1%2FESP32-H2-MINI-1%2Fbasic%2FESP32-H2-MINI-1-basic.kicad_pcb)

### 部品表

| Reference   | Name                                           | Quantity |
| ----------- | ---------------------------------------------- | -------- |
| C1,C6,C8,C9 | Capacitor 0603 10uF                            | 4        |
| C2,C7       | Capacitor 0603 0.1uF                           | 2        |
| C3          | Capacitor 0603 1uF                             | 1        |
| C4,C5       | Capacitor 0603 10pF                            | 2        |
| D1          | LED 0805 Blue                                  | 1        |
| D2          | Schottky barrier diode SOD-123W PMEG2010ER,115 | 1        |
| J1          | Box Pin Header 2x3 Pitch 1.27mm                | 1        |
| J2          | USB Type-C Receptacle                          | 1        |
| R1,R2       | Register 0603 10Ω                              | 2        |
| R3,R4,R5,R6 | Register 0603 10kΩ                             | 4        |
| R7,R8       | Register 0603 5.1kΩ                            | 2        |
| SW1,SW2     | Button SKRPABE010                              | 2        |
| U1          | WiFi MCU Module ESP32-H2-MINI-1                | 1        |
| U2          | Regulator 3.3V SOT-89 AMS1117-3.3              | 1        |
| Y1          | Crystal 3215 32kHz                             | 1        |

### ピンマップ

## v1.0.0

- Semantics [pdf](./ESP32-H2-MINI-1-basic_v1.0.0_semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-h2-mini-1-basic%2Fv1.0.0%2FESP32-H2-MINI-1%2Fbasic%2FESP32-H2-MINI-1-basic.kicad_sch)
- PCB [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-h2-mini-1-basic%2Fv1.0.0%2FESP32-H2-MINI-1%2Fbasic%2FESP32-H2-MINI-1-basic.kicad_pcb)

### 部品表

| Reference   | Name                                           | Quantity |
| ----------- | ---------------------------------------------- | -------- |
| C1,C6,C8,C9 | Capacitor 0603 10uF                            | 4        |
| C2,C7       | Capacitor 0603 0.1uF                           | 2        |
| C3          | Capacitor 0603 1uF                             | 1        |
| C4,C5       | Capacitor 0603 10pF                            | 2        |
| D1          | LED 0805 Blue                                  | 1        |
| D2          | Schottky barrier diode SOD-123W PMEG2010ER,115 | 1        |
| J1          | Box Pin Header 2x3 Pitch 1.27mm                | 1        |
| J2          | USB Type-C Receptacle                          | 1        |
| R1,R2       | Register 0603 10Ω                              | 2        |
| R3,R4,R5,R6 | Register 0603 10kΩ                             | 4        |
| R7,R8       | Register 0603 5.1kΩ                            | 2        |
| SW1,SW2     | Button SKRPABE010                              | 2        |
| U1          | WiFi MCU Module ESP32-H2-MINI-1                | 1        |
| U2          | Regulator 3.3V SOT-89 AMS1117-3.3              | 1        |
| Y1          | Crystal 2012 32kHz                             | 1        |

### ピンマップ

Parts:
C1, C5, C8, C9: 10u; Capacitor_0805_2012
C2, C4: 0.1u; Capacitor_0805_2012
C3: 1u; Capacitor_0805_2012
C6, C7: 12p; Capacitor_0805_2012
CH1, CH2: Pin_13; PinOut_Pin_12
D1: Blue; LED_0805_2012
D2: PMEG2010ER,115; Package_SOD123W
J1: ESP-Prog-ProgramCOM_RECV; Connector_BoxPinHeader_2x03_P1.27mm
J2: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
R1, R2: 10; Register_0805_2012
R3, R4, R5, R8: 10k; Register_0805_2012
R6, R7: 5.1k; Register_0805_2012
SW1, SW2: SW_Push; Switch_SKRPABE010
U1: ESP32-H2-MINI-1; ESP32-C3-MINI-1_HandSoldering
U2: AMS1117; Package_SOT-223-3
Y1: 32k; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C1.1, C2.1, C8.1, CH1.1, R8.1, U1.3 (3V3), U2.2 (VO)
+5V: CH1.12, D2.2 (A), J1.2 (VCC), J2.1 (VBUS)
/EN: C3.1, CH1.5, J1.1 (EN), R3.2, SW2.1, U1.8 (EN)
/GPIO0: CH1.6, U1.9 (GPIO0/FSPIQ)
/GPIO1: CH1.7, U1.10 (GPIO1/FSPICS0/ADC1_CH0)
/GPIO2: CH1.3, U1.5 (GPIO2/FSPIWP/ADC1_CH1/MTMS)
/GPIO3: CH1.4, U1.6 (GPIO3/FSPIHD/ADC1_CH2/MTDO)
/GPIO4: CH2.11, U1.18 (GPIO4/FSPICLK/ADC1_CH3/MTCK)
/GPIO5: CH2.10, U1.19 (GPIO5/FSPID/ADC1_CH4/MTDI)
/GPIO8: CH2.7, R5.2, U1.22 (GPIO8)
/GPIO9: CH2.6, J1.6 (IO0), R4.2, SW1.1, U1.23 (GPIO9)
/GPIO10: CH2.9, U1.20 (GPIO10/ZCD0)
/GPIO11: CH2.8, U1.21 (GPIO11/ZCD1)
/GPIO12: CH1.8, U1.16 (GPIO12)
/GPIO13-XTAL: C7.2, U1.12 (GPIO13/XTAL_32K_P), Y1.2
/GPIO14-XTAL: C6.2, U1.13 (GPIO14/XTAL_32K_N), Y1.1
/GPIO22: CH2.5, U1.24 (GPIO22)
/GPIO23: CH2.3, J1.5 (RXD0), U1.30 (GPIO23/FSPICS1/U0RXD)
/GPIO24: CH2.2, J1.3 (TXD0), U1.31 (GPIO24/FSPICS2/U0TXD)
/GPIO25: CH2.4, U1.25 (GPIO25/FSPICS3)
/USB_DM: J2.2 (D-), R2.2
/USB_DP: J2.3 (D+), R1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, CH1.2, CH1.10, CH1.11, CH2.1, CH2.12, D1.1 (K), J1.4 (GND), J2.4 (GND), R6.2, R7.2, SW1.2, SW2.2, U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U2.1 (GND)
unnamed: D1.2 (A), R8.2
unnamed: C9.1, D2.1 (K), U2.3 (VI)
unnamed: J2.5 (CC1), R6.1
unnamed: J2.6 (CC2), R7.1
unnamed: R2.1, U1.26 (GPIO26/FSPICS4/USB_D-)
unnamed: R1.1, U1.27 (GPIO27/FSPICS5/USB_D+)
VBAT: C4.1, C5.1, CH1.9, R3.1, R4.1, R5.1, U1.15 (VBAT)

Notes on the sheet:
Reset/Boot
USB
Power

Board: 2 copper layers, 36.8 x 41.9 mm, 35 parts (0 on the bottom side), 30 nets.

Other parts of the board:
M1, M2, M3, M4, M5, M6: Hole_M2_2.0
MISC-ICON: LOGO; Logo_74th_4mm

## KiCad design ESP32-Writer-CH340G/ESP32-Writer-CH340G.kicad_pcb

Parts:
C1, C2: 1u; Capacitor_0805_2012
C3, C4, C5: 100n; Capacitor_0805_2012
C8: 22u; Capacitor_0805_2012
D1: BLUE; LED_0805_2012
D2: NC(1N4148W); Package_SOD23_Diode
D3: PMEG2010ER; Package_SOD123W
F1, F2: Polyfuse; Package_Fuse_1812_4532m
J1: ESP-Prog-ProgramCOM-SEND; Connector_BoxPinHeader_2x03_P1.27mm
J2, J4: USB2.0_C; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
J3: UART-OUTPUT; PinOut_Pin_8
Q1, Q2: 2N7002; Package_SOT-23
R1: 10k; Register_0805_2012
R2, R3, R4, R5: 5.1k; Register_0805_2012
R6: 10(470); Register_0805_2012
R7, R8, R9: 10; Register_0805_2012
SW1: SK-12D02-G020; Switch_Slide_SK-12D02-G020
U1: AMS1117-3.3; Package_SOT-223-3
U2: CH340C; Package_SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C2.1, J3.3 (3V3), SW1.3 (C), U1.2 (VO)
+5V: C1.1, C8.1, D3.1 (K), F1.2, J1.2 (VCC), J3.2 (5V), R1.1, SW1.1 (A), U1.3 (VI)
/BOOT: J1.6 (IO0), J3.8 (BOOT), Q1.3 (D)
/DM: R9.2, U2.6 (UD-)
/DP: R8.2, U2.5 (UD+)
/DTR: Q1.2 (S), Q2.1 (G), U2.13 (DTR)
/RESET: C5.1, J1.1 (EN), J3.7 (RESET), Q2.3 (D)
/RTS: Q1.1 (G), Q2.2 (S), U2.14 (RTS)
/RXD: J1.3 (RXD0), J3.5 (RXD), R6.2
/TXD: J1.5 (TXD0), J3.6 (TXD), R7.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, D1.1 (K), J1.4 (GND), J2.4 (GND), J3.1 (GND), J3.4 (GND), J4.4 (GND), R2.2, R3.2, R4.2, R5.2, U1.1 (GND), U2.1 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R6.1, U2.3 (RXD)
unnamed: D2.1 (K), R7.1, U2.2 (TXD)
unnamed: D3.2 (A), F2.2
unnamed: J2.5 (CC1), R2.1
unnamed: J2.6 (CC2), R3.1
unnamed: F1.1, J2.1 (VBUS)
unnamed: J4.5 (CC1), R4.1
unnamed: J4.6 (CC2), R5.1
unnamed: J4.3 (D+), R8.1
unnamed: J4.2 (D-), R9.1
unnamed: F2.1, J4.1 (VBUS)
unnamed: C3.1, U2.4 (V3)
VCC: C4.1, SW1.2 (B), U2.16 (VCC)

Notes on the sheet:
Power Indicator
RXDをUPDI化する場合には以下に変更する - R6: 470 - R7: NC - D2: 1N4148W
Pin Header
Power USB
CH340
Control USB
Auto ESP32 Control
ESP32では、BOOT0がHighの状態で、RESETがLow→Highになる必要がある
UART Port

Board: 2 copper layers, 54.6 x 31.1 mm, 30 parts (0 on the bottom side), 25 nets.

Other parts of the board:
MISC-ICON: LOGO; Logo_74th_5mm
