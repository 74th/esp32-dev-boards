# Repository 74th/esp32-dev-boards (continued)

## KiCad design ESP32-H2-MINI-1/with-lipo/ESP32-H2-MINI-1.kicad_pcb

Parts:
C1, C2, C4, C5, C6, C10, C11, C13: 10u; Capacitor_0805_2012
C3: 100n; Capacitor_0805_2012
C7, C8: 10p; Capacitor_0805_2012
C9, C12, C14: 1u; Capacitor_0805_2012
D1: Red; LED_0805_2012
D2: Blue; LED_0805_2012
D3, D4: PMEG2010ER,115; Package_SOD123W
D5: Yellow Green; LED_0805_2012
J1: JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J2: ESP-Prog-ProgramCOM_RECV; BoxPinHeader_2x03_P1.27mm_Vertical
J3: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
R1, R6, R15, R16: 5.1k; Register_0603_1608
R2: 2k; Register_0603_1608
R3: 1M; Register_0603_1608
R4: 4.7M; Register_0603_1608
R5, R7, R12, R13, R14: 10k; Register_0603_1608
R8, R9: 0(NC); Register_0603_1608
R10, R11: 27; Register_0603_1608
R17: 1k; Register_0603_1608
SW1, SW2: SW_Push; Switch_SKRPABE010
U1: ESP32-H2-MINI-1
U2: MCP73831-2-OT; SOT-23-5
U3, U4: AMS1117; SOT-223-3_TabPin2
Y1: 32k; Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering

Connections:
+3V3: C1.1, C5.1, C12.1, R7.1, U1.3 (3V3), U3.2 (VO)
+5V: J2.2 (VCC)
+BATT: C6.1, J1.1 (+), R4.1, R12.1, R13.1, R14.1, U2.3 (V_{BAT})
/EN: C9.1, J2.1 (EN), R13.2, SW2.1, U1.8 (EN)
/GPIO0: U1.9 (GPIO0/FSPIQ)
/GPIO1: U1.10 (GPIO1/FSPICS0/ADC1_CH0)
/GPIO2: C3.1, R3.1, R4.2, U1.5 (GPIO2/FSPIWP/ADC1_CH1/MTMS)
/GPIO3: U1.6 (GPIO3/FSPIHD/ADC1_CH2/MTDO)
/GPIO4: U1.18 (GPIO4/FSPICLK/ADC1_CH3/MTCK)
/GPIO5: U1.19 (GPIO5/FSPID/ADC1_CH4/MTDI)
/GPIO8: R14.2, U1.22 (GPIO8)
/GPIO9: J2.6 (IO0), R12.2, SW1.1, U1.23 (GPIO9)
/GPIO10: U1.20 (GPIO10/ZCD0)
/GPIO11: U1.21 (GPIO11/ZCD1)
/GPIO12: U1.16 (GPIO12)
/GPIO13: R9.1
/GPIO13-XTAL: C7.2, R9.2, U1.12 (GPIO13/XTAL_32K_P), Y1.2
/GPIO14: R8.1
/GPIO14-XTAL: C8.2, R8.2, U1.13 (GPIO14/XTAL_32K_N), Y1.1
/GPIO22: U1.24 (GPIO22)
/GPIO23: J2.5 (RXD0), U1.30 (GPIO23/FSPICS1/U0RXD)
/GPIO24: J2.3 (TXD0), U1.31 (GPIO24/FSPICS2/U0TXD)
/GPIO25: R5.1, R6.2, U1.25 (GPIO25/FSPICS3)
/USB_DM: J3.2 (D-), R11.2
/USB_DP: J3.3 (D+), R10.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D2.1 (K), D5.1 (K), J1.2 (-), J2.4 (GND), J3.4 (GND), R2.2, R3.2, R5.2, R15.2, R16.2, SW1.2, SW2.2, U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U2.2 (V_{SS}), U3.1 (GND), U4.1 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), U2.1 (STAT)
unnamed: D2.2 (A), R7.2
unnamed: C4.1, D3.1 (K), U3.3 (VI)
unnamed: C10.1, D4.1 (K), U4.3 (VI)
unnamed: D5.2 (A), R17.2
unnamed: J3.5 (CC1), R15.1
unnamed: J3.6 (CC2), R16.1
unnamed: R11.1, U1.26 (GPIO26/FSPICS4/USB_D-)
unnamed: R10.1, U1.27 (GPIO27/FSPICS5/USB_D+)
unnamed: R2.1, U2.5 (PROG)
VBAT: C11.1, C13.1, C14.1, R17.1, U1.15 (VBAT), U4.2 (VO)
VCC: D3.2 (A), R1.1
VUSB: C2.1, D4.2 (A), J3.1 (VBUS), R6.1, U2.4 (V_{DD})

Notes on the sheet:
TODO: 4V以上の給電が必要ｎなので、5Vの手前でバッテリーを繋ぐ
USB検出
バッテリー検出

Board: 2 copper layers, 46 parts (0 on the bottom side), 28 nets, no tracks yet.

## KiCad design ESP32-C6-WROOM-1/ESP32-C6-WROOM-1.kicad_pcb

File ESP32-C6-WROOM-1/README.md:

# ESP32-C6-WROOM-1 Dev Board

ESP32-C6-WROOM-1 を使った開発ボード

- 10 ピンブレッドボードに挿しても、左右 1 ピン空いている
- ESP-Prog の USB シリアル変換のボックスピンヘッダを持つ
- USB Type-C をもつ

BOOTH でモジュール付きキットを販売中です。<br/>
https://74th.booth.pm/items/5777580

## v1.0.0

- 回路図 [pdf](./ESP32-C6-WROOM-1_v1.0.0_semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-c6-wroom-1%2Fv1.0.0%2FESP32-C6-WROOM-1%2FESP32-C6-WROOM-1.kicad_sch)
- PCB [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-c6-wroom-1%2Fv1.0.0%2FESP32-C6-WROOM-1%2FESP32-C6-WROOM-1.kicad_pcb)

### BOM

| Reference   | Name                                           | Quantity |
| ----------- | ---------------------------------------------- | -------- |
| C1          | Capacitor 0805 22uF                            | 1        |
| C2,C3       | Capacitor 0805 10uF                            | 2        |
| C4          | Capacitor 0805 1uF                             | 1        |
| D1          | Schottky barrier diode SOD-123W PMEG2010ER,115 | 1        |
| D2          | LED 0805 Blue                                  | 1        |
| J1          | Box Pin Header 2x3 Pitch 1.27mm                | 1        |
| J2          | USB Type-C Receptacle                          | 1        |
| R1,R6,R7,R8 | Register 0805 10kΩ                             | 4        |
| R2,R3       | Register 0805 10Ω                              | 2        |
| R4,R5       | Register 0805 5.1kΩ                            | 2        |
| SW1,SW2     | Button SKRPABE010                              | 2        |
| U1          | WiFi MCU Module ESP32-C6-WROOM-1               | 1        |
| U2          | Regulator 3.3V SOT-223 AMS1117-3.3             | 1        |

## ピンマップ

Parts:
C1: 22u; Capacitor_0805_2012
C2, C3: 10u; Capacitor_0805_2012
C4: 1u; Capacitor_0805_2012
CH1, CH2: Pin_13; PinOut_Pin_13
D1: PMEG2010ER,115; Package_SOD123W
D2: Blue; LED_0805_2012
J1: ESP-Prog-ProgramCOM_RECV; Connector_BoxPinHeader_2x03_P1.27mm
J2: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
R1, R6, R7, R8: 10k; Register_0805_2012
R2, R3: 27; Register_0805_2012
R4, R5: 5.1k; Register_0805_2012
SW1, SW2: SW_Push; Switch_SKRPABE010
U1: ESP32-C6-WROOM-1
U2: AMS1117; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C3.1, CH1.2, R1.1, R6.2, R7.2, R8.2, U1.2 (3V3), U2.2 (VO)
+5V: C2.1, CH1.13, D1.1 (K), J1.2 (VCC), U2.3 (VI)
/EN: C4.1, CH1.3, J1.1 (EN), R6.1, SW1.1, U1.3 (EN/CHIP_PU)
/GPIO0: CH1.8, U1.8 (GPIO0/ADC1_CH0/XTAL_32K_P)
/GPIO1: CH1.9, U1.9 (GPIO1/ADC1_CH1/XTAL_32K_N)
/GPIO2: CH2.2, U1.27 (GPIO2/ADC1_CH2)
/GPIO3: CH2.3, U1.26 (GPIO3/ADC1_CH3)
/GPIO4: CH1.4, U1.4 (MTMS/GPIO4/ADC1_CH4)
/GPIO5: CH1.5, U1.5 (MTDI/GPIO5/ADC1_CH5)
/GPIO6: CH1.6, U1.6 (MTCK/GPIO6/ADC1_CH6)
/GPIO7: CH1.7, U1.7 (MTDO/GPIO7)
/GPIO8: CH1.10, R8.1, U1.10 (GPIO8)
/GPIO9: CH2.13, J1.6 (IO0), R7.1, SW2.1, U1.15 (GPIO9)
/GPIO10: CH1.11, U1.11 (GPIO10)
/GPIO11: CH1.12, U1.12 (GPIO11)
/GPIO15: CH2.6, U1.23 (GPIO15)
/GPIO18: CH2.12, U1.16 (GPIO18)
/GPIO19: CH2.11, U1.17 (GPIO19)
/GPIO20: CH2.10, U1.18 (GPIO20)
/GPIO21: CH2.9, U1.19 (GPIO21)
/GPIO22: CH2.8, U1.20 (GPIO22)
/GPIO23: CH2.7, U1.21 (GPIO23)
/RXD: CH2.5, J1.5 (RXD0), U1.24 (U0RXD/GPIO17)
/TXD: CH2.4, J1.3 (TXD0), U1.25 (U0TXD/GPIO16)
/USB_DM: J2.2 (D-), R2.2
/USB_DP: J2.3 (D+), R3.2
GND: C1.2, C2.2, C3.2, C4.2, CH1.1, CH2.1, D2.1 (K), J1.4 (GND), J2.4 (GND), R4.1, R5.1, SW1.2, SW2.2, U1.1 (GND), U1.28 (GND), U1.29 (GND), U2.1 (GND)
unnamed: D1.2 (A), J2.1 (VBUS)
unnamed: D2.2 (A), R1.2
unnamed: J2.5 (CC1), R5.2
unnamed: J2.6 (CC2), R4.2
unnamed: R2.1, U1.13 (GPIO12/USB_D-)
unnamed: R3.1, U1.14 (GPIO13/USB_D+)

Notes on the sheet:
PinOut
ESP32-C6 Module
ESP-Prog Port
USB Power
Download Mode Select

Board: 2 copper layers, 25.4 x 36.8 mm, 24 parts (16 on the bottom side), 33 nets.

Other parts of the board:
MISC-ACCOUNTTEXT: Logo_74th_text
MISC-ICON: LOGO; Logo_74th_4mm

## KiCad design ESP32-C3-MINI-1/ESP32-C3-MINI-1.kicad_pcb

File ESP32-C3-MINI-1/README.md:

# ESP32-C3-Micro

ESP32-C3-MINI-1 を使った開発ボード

## v1.2.0

- 回路図 Semantics [pdf](ESP32-C3-MINI-1-dev-board-semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32c3micro%2Fv1.2.0%2FESP32-C3-MINI-1%2FESP32-C3-MINI-1-panelized.kicad_sch)
- PCB [pdf](ESP32-C3-MINI-1-dev-board-pcb.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32c3micro%2Fv1.2.0%2FESP32-C3-MINI-1%2FESP32-C3-MINI-1-panelized.kicad_pcb)

### 部品表

BoxPinHeader は ESP-Prog の UART と接続できます。

| 指定子   | 部品                             | 数量 |
| -------- | -------------------------------- | ---- |
| J1       | BoxPinHeader                     | 1    |
| SW1,SW2  | Tactile Button SKRPABE010        | 2    |
| D1       | 0805 LED Blue                    | 1    |
| J2       | USB-C-12-Pin-SMD                 | 1    |
| R1,R2    | 0805 Register 10kR               | 2    |
| R3,R4    | 0805 Register 0R                 | 2    |
| R5       | 0805 Register 1kR                | 1    |
| R6,R7    | 0805 Register 5.1kR              | 2    |
| C1,C5    | 0805 Capacitor 10uF              | 2    |
| C2,C3,C4 | 0805 Capacitor 100nF             | 3    |
| U2       | SOT-89 LDO Regulator AMS1117-3.3 | 1    |
| U1       | ESP32-C3-MINI-1                  | 1    |

Parts:
C1, C5: 10u; Capacitor_0805_2012
C2, C3, C4: 100n; Capacitor_0805_2012
CH1: ProMicro-LeftPin; ProMicro_LIKE_LEFT
CH2: ProMicro-RightPin; ProMicro_LIKE_RIGHT
D1: PWR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: ESPProg-UART; BoxPinHeader_2x03_P1.27mm_Vertical
J2: USB2.0_C; USB-C-12-Pin-SMD
R1, R2: 10k; Register_0805_2012
R3, R4: 0; Register_0805_2012
R5: 1k; Register_0805_2012
R6, R7: 5.1k; Register_0805_2012
SW1: RESET; SKRPABE010
SW2: BOOT; SKRPABE010
U1: ESP32-C3-MINI-1
U2: AMS1117-3.3; Regulator_AMS1117_SOT-89

Connections:
+3V3: C1.1, C4.1, CH2.9 (3V3), R1.2, R2.2, R5.2, U1.3 (3V3), U2.2 (VO)
+5V: C5.1, CH2.12 (RAW), J1.2 (VCC), J2.1 (VBUS), U2.3 (VI)
CHIP_PU: CH2.10 (~RESET), J1.1 (ESP_EN)
GND: C2.2, C3.2, C4.2, C5.2, CH1.3 (GND), CH1.4 (GND), CH1.11 (8/A8), CH1.12 (9/A9), CH2.1 (10/A10), CH2.11 (GND), D1.1 (K), J1.4 (GND), J2.4 (GND), R6.1, R7.1, SW1.1, SW2.1, U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U2.1 (GND)
GPIO0: CH1.6 (3/SCL), J1.6 (ESP_BOOT), U1.12 (GPIO0/ADC1_CH0/XTAL_32K_P)
GPIO1: CH1.5 (2/SDA), U1.13 (GPIO1/ADC1_CH1/XTAL_32K_N)
GPIO2: CH2.5 (18/A0), U1.5 (GPIO2/ADC1_CH2)
GPIO3: CH2.6 (19/A1), U1.6 (GPIO3/ADC1_CH3)
GPIO4: CH2.7 (20/A2), U1.18 (GPIO4/ADC1_CH4)
GPIO5: CH2.8 (21/A3), U1.19 (GPIO5/ADC2_CH0)
GPIO6: CH2.2 (16/SPI_MOSI), U1.20 (GPIO6)
GPIO7: CH2.3 (14/SPI_MISO), U1.21 (GPIO7)
GPIO8: CH1.7 (4/A6), R2.1, U1.22 (GPIO8)
GPIO9: C2.1, CH2.4 (15/SPI_SCK), SW2.2, U1.23 (GPIO9)
GPIO10: CH1.8 (5), U1.16 (GPIO10)
GPIO18: CH1.9 (6/A7), R4.1, U1.26 (GPIO18/USB_D-)
GPIO19: CH1.10 (7), R3.1, U1.27 (GPIO19/USB_D+)
unnamed: D1.2 (A), R5.1
unnamed: J2.5 (CC1), R7.2
unnamed: J2.6 (CC2), R6.2
unnamed: J2.3 (D+), R3.2
unnamed: J2.2 (D-), R4.2
unnamed: C3.1, R1.1, SW1.2, U1.8 (EN/CHIP_PU)
U0RXD: CH1.2 (0/RX), J1.5 (ESP_RXD), U1.30 (GPIO20/U0RXD)
U0TXD: CH1.1 (1/TX), J1.3 (ESP_TXD), U1.31 (GPIO21/U0TXD)

Board: 2 copper layers, 20.3 x 46.4 mm, 23 parts (13 on the bottom side), 25 nets.

Other parts of the board:
mouse-bite-3mm-slot, mouse-bite-3mm-slot#2: VAL**; mouse-bite-2.54mm-slot

## KiCad design ESP32-WROOM-32/ESP32-WROOM-32.kicad_pcb

File ESP32-WROOM-32/README.md:

# ESP32 Micro

- やっぱり S3，C3 でもない素の ESP32 じゃないと動かないことが多いので、ESP32 を使いたい
- ProMicro のピン配置がわかりやすい

## v1.0.0

- semantics 回路図 [pdf](ESP32-WROOM-32-v1.0.0-pcb.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-wroom-32%2Fv1.0.0%2FESP32-WROOM-32%2FESP32-WROOM-32.kicad_sch)
- PCB [pdf](ESP32-WROOM-32-v1.0.0-semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32-dev-boards%2Fblob%2Fesp32-wroom-32%2Fv1.0.0%2FESP32-WROOM-32%2FESP32-WROOM-32.kicad_pcb)

### Parts List 部品リスト

| id       | parts                                   | number |
| -------- | --------------------------------------- | ------ |
| U1       | ESP32-WROOM-32                          | 1      |
| U2       | SOT-223 3.3V Regulator AMS1117-3.3      | 1      |
| D1,D2    | 0805 LED PWR                            | 2      |
| D3       | SMA Diode                               | 1      |
| C1,C4    | 0805 capacitor 100n                     | 2      |
| C2,C5    | 0805 capacitor 10u                      | 2      |
| C3       | 0805 capacitor 1u                       | 1      |
| R1,R2,R3 | 0805 register 10k                       | 3      |
| R4,R5    | 0805 register 5.1k                      | 2      |
| J1       | ESP-Prog UART compatible box pin header | 1      |
| J2       | USB Type-C socket                       | 1      |
| SW1      | Push Switch BT                          | 1      |
| SW2      | Push Switch RST                         | 1      |

Board: 2 copper layers, 25.4 x 34.3 mm, 21 parts (12 on the bottom side), 29 nets.

Parts:
C1, C4: 100n; Capacitor_0805_2012
C2, C5: 10u; Capacitor_0805_2012
C3: 1u; Capacitor_0805_2012
CH1: ProMicro-LeftPin; ProMicro_LIKE_LEFT_NO_GND
CH2: ProMicro-RightPin; ProMicro_LIKE_RIGHT
D1, D2: PWR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: D; D_SMA
J1: ESP-Prog-ProgramCOM-RECV; BoxPinHeader_2x03_P1.27mm_Vertical
J2: USB2.0_C_v3; USB-C-12-Pin-SMD
R1, R2, R3: 10k; Register_0805_2012
R4, R5: 5.1k; Register_0805_2012
SW1: BT; SKRPABE010
SW2: RST; SKRPABE010
U1: ESP32-WROOM-32D
U2: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C2.1, CH2.9 (3V3), R1.2, R2.2, U1.2 (VDD), U2.2 (VO)
+5V: C4.1, C5.1, CH2.12 (RAW), D3.1 (K), J1.2 (VCC), U2.3 (VI)
/VUSB: D3.2 (A), J2.1 (VBUS)
EN: C3.1, CH2.10 (~RESET), J1.1 (EN), R1.1, SW2.1, U1.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, CH2.11 (GND), D1.1 (K), D2.1 (K), J1.4 (GND), J2.4 (GND), R4.2, R5.2, SW1.1, SW2.2, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.1 (GND)
GPIO0: CH1.3 (Alt1), J1.6 (IO0), SW1.2, U1.25 (IO0)
GPIO2: CH1.4 (Alt2), R3.2, U1.24 (IO2)
GPIO4: CH1.7 (4/A6), U1.26 (IO4)
GPIO5: CH2.1 (10/A10), U1.29 (IO5)
GPIO12: CH2.5 (18/A0), U1.14 (IO12)
GPIO13: CH2.6 (19/A1), U1.16 (IO13)
GPIO14: CH2.7 (20/A2), U1.13 (IO14)
GPIO15: CH2.8 (21/A3), U1.23 (IO15)
GPIO18: CH2.4 (15/SPI_SCK), U1.30 (IO18)
GPIO19: CH2.3 (14/SPI_MISO), U1.31 (IO19)
GPIO21: CH1.5 (2/SDA), U1.33 (IO21)
GPIO22: CH1.6 (3/SCL), U1.36 (IO22)
GPIO23: CH2.2 (16/SPI_MOSI), U1.37 (IO23)
GPIO25: CH1.10 (7), U1.10 (IO25)
GPIO26: CH1.11 (8/A8), U1.11 (IO26)
GPIO27: CH1.12 (9/A9), U1.12 (IO27)
GPIO32: CH1.8 (5), U1.8 (IO32)
GPIO33: CH1.9 (6/A7), U1.9 (IO33)
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R2.1
unnamed: J2.5 (CC1), R5.1
unnamed: J2.6 (CC2), R4.1
U0RXD: CH1.2 (0/RX), J1.5 (RXD0), U1.34 (RXD0/IO3)
U0TXD: CH1.1 (1/TX), J1.3 (TXD0), U1.35 (TXD0/IO1)

## Commit log

2022-05-14 ESP32-S3
2022-05-14 update SILK
2022-05-14 update path
2022-05-14 ESP32-C3
2022-05-15 order
2022-05-15 oreder 2022-05-16
2022-06-04 ESP32 writer
2022-06-04 update documents
2022-06-11 esp32-writer
2022-09-04 ESP32-C3-WROOM-02
2022-09-14 C3-MINI-1
2022-09-19 USB Serial
2022-09-19 ESP32-S3-dev-board
2022-09-19 update parts
2022-09-28 C3-WROOM-02
2022-10-23 D1 の注意を追加
2022-10-23 ESP32-C3-WROOM-02-writer
2022-10-27 ESP32-C3-FlexPin-Writer
2022-10-27 fix D1, IO14
2022-12-08 esp32-c3 dev board
2022-12-08 update photo
2022-12-09 update BOOTH Link
2022-12-31 update ESP32-Writer
2023-02-12 type-b
2023-02-12 type ch340g
2023-02-12 copy
2023-02-12 replace usb type-c
2023-03-08 esp32-write-G/v2.1.2
2023-03-16 esp32-writer-G/v2.1.2
2023-04-06 ch340x
2023-04-08 ESP32-Writer-CH340X/v1.0.0
2023-04-17 before free routing
2023-04-17 esp32-wroom-32/v1.0.0
2023-04-17 new ver
2023-05-27 before routing
2023-05-27 before panelize
2023-06-04 v1.2.0
2023-06-04 ESP32-WROOM32
2023-06-10 ESP32C3Micro/v1.2.0
2023-06-19 ESP32 Micro
2023-06-20 update Document
2023-07-22 add kicanvas
2024-01-25 update AKIZUKI URL
2024-04-29 esp32-writer/v3.0.0
2024-05-11 esp32-c6-wroom-1/1.0.0
2024-05-20 ESP32-H2-MINI-1-basic/1.0.0
2024-05-20 esp32-h2-mini-1-with-lipo
2024-05-20 add title
2024-05-25 small fix
2024-05-27 esp32-h2-mini-1-basic/v1.0.1
2024-06-07 ESP32-H2-MINI-1-basic-b/1.0.0
2024-06-07 esp3s-c3-devboard/v1.2.0
2024-09-09 ESP-Writer-CH9102F v1.0.0
2024-09-17 copy from ch32v003fun
2024-09-26 auto download
2024-09-27 no using PLL
2024-09-27 add firmware binary
2024-09-28 esp32-writer-ch9102f
2024-09-28 update firmware
2024-10-27 rts to reset
2024-10-31 add bom
2025-12-30 esp32-writer-ch9102f/v1.1.0
2025-12-30 esp3s-c3-devboard/v1.2.1
